Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: ER-UBIS-000176-1-E-INQU-BIM-3D-01-A.ifc
Time: 2025-09-30T10:22:35
Made in: SierraSoft - BIM Exchange - 10.0.0.2509181
Comment: SierraSoft Infra Design Studio (4.0.0.2509181)

# IfcBuildingElementProxy, DTM-sdf
In: Sito
Testo - WBS_COMMESSA: UBIS176; WBS_COMPONENTE-OPERA: DTM; WBS_DISCIPLINA: INQU; WBS_FASE: E; WBS_LOTTO: 1; WBS_PARTE-OPERA: Budrie; WBS_SUBOPERA: SDF
Fasi - Fase di creazione: Stato di fatto
Identificazione - Sistema di riferimento: Gauss-Boaga fuso Ovest
