Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: IFC4X3_ADD2
File name: ER-UBIS-000176-1-E-INQU-BIM-3D-02-A.ifc
Time: 2025-09-30T10:22:55
Made in: SierraSoft - BIM Exchange - 10.0.0.2509181
Comment: SierraSoft Infra Design Studio (4.0.0.2509181)

# IfcGeographicElement (373)
In: Sito
PredefinedType: TERRAIN
Testo - WBS_COMMESSA: UBIS176; WBS_FASE: E; WBS_LOTTO: 1; WBS_PARTE-OPERA: Budrie
Fasi - Fase di creazione: Stato di costruzione
Name | Coordinata X (m) | Coordinata Y (m) | WBS_COMPONENTE-OPERA | WBS_DISCIPLINA | WBS_SUBOPERA | Profilo AU | Larghezza (b) (m) | Altezza (h) (m) | Spessore (t) (m) | Spessore (s) (m) | Massa singola palancola (kg/m) | Massa parete (kg/mq) | Materiale
2 x Palancole | 1674723 | 4940004 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674724 | 4940003 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674724 | 4940001 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674725 | 4940000 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674725 | 4939998 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674725 | 4939997 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674726 | 4939995 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674726 | 4939994 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674726 | 4939992 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674727 | 4939991 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674727 | 4939990 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674727 | 4939988 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674728 | 4939987 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674728 | 4939985 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674728 | 4939984 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674729 | 4939982 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674729 | 4939981 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674729 | 4939979 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674730 | 4939978 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674730 | 4939976 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674730 | 4939975 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674730 | 4939973 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674731 | 4939972 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
4 x Palancole | 1674731 | 4939970 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674627 | 4939982 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674628 | 4939982 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674630 | 4939983 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674631 | 4939983 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674633 | 4939984 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674634 | 4939984 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674635 | 4939985 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674637 | 4939985 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674638 | 4939986 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674640 | 4939986 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674641 | 4939986 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674643 | 4939987 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674644 | 4939987 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674646 | 4939987 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674647 | 4939988 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674649 | 4939988 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674650 | 4939988 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674651 | 4939989 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674653 | 4939989 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674654 | 4939989 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674656 | 4939990 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674657 | 4939990 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674659 | 4939990 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674660 | 4939991 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674662 | 4939991 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674663 | 4939991 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674665 | 4939992 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674666 | 4939992 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674668 | 4939992 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674669 | 4939993 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674670 | 4939993 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674672 | 4939993 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674673 | 4939994 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674675 | 4939994 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674676 | 4939994 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674678 | 4939995 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674679 | 4939995 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674681 | 4939995 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674682 | 4939996 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674684 | 4939996 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674685 | 4939996 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674687 | 4939997 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674688 | 4939997 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674690 | 4939997 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674691 | 4939998 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674692 | 4939998 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674694 | 4939998 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674695 | 4939999 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674697 | 4939999 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674698 | 4939999 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674700 | 4940000 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674701 | 4940000 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674703 | 4940000 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674704 | 4940001 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674706 | 4940001 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674707 | 4940001 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674709 | 4940002 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674710 | 4940002 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674711 | 4940002 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674713 | 4940003 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674714 | 4940003 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674716 | 4940003 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674717 | 4940004 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674719 | 4940004 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674720 | 4940004 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674722 | 4940005 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
4 x Palancole | 1674723 | 4940005 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674627 | 4939981 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674627 | 4939979 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674628 | 4939978 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674628 | 4939977 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674629 | 4939975 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674629 | 4939974 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674630 | 4939972 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674630 | 4939971 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674631 | 4939970 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674631 | 4939968 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674632 | 4939967 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674632 | 4939965 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674633 | 4939964 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674633 | 4939962 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674634 | 4939961 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674634 | 4939960 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674635 | 4939958 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674635 | 4939957 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674636 | 4939955 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674636 | 4939954 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674637 | 4939953 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674638 | 4939951 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674638 | 4939950 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674639 | 4939948 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674639 | 4939947 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674640 | 4939946 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674640 | 4939944 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674641 | 4939943 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
4 x Palancole | 1674641 | 4939941 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674729 | 4939969 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674728 | 4939969 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674726 | 4939969 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674725 | 4939968 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674723 | 4939968 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674722 | 4939968 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674720 | 4939967 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674719 | 4939967 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674717 | 4939967 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674716 | 4939966 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674714 | 4939966 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674713 | 4939966 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674712 | 4939965 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674710 | 4939965 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674709 | 4939965 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674707 | 4939964 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674706 | 4939964 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674704 | 4939964 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674703 | 4939963 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674701 | 4939963 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674700 | 4939963 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674698 | 4939962 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674697 | 4939962 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674695 | 4939962 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674694 | 4939961 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674693 | 4939961 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674691 | 4939961 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674690 | 4939960 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674688 | 4939960 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674687 | 4939960 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674685 | 4939959 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674684 | 4939959 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674682 | 4939959 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674681 | 4939958 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674679 | 4939958 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674678 | 4939958 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674676 | 4939957 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674675 | 4939957 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674673 | 4939957 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674672 | 4939956 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674671 | 4939956 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674669 | 4939956 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674668 | 4939955 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674666 | 4939955 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674665 | 4939955 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674663 | 4939954 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674662 | 4939954 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674660 | 4939954 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674659 | 4939954 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674657 | 4939953 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674656 | 4939953 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674654 | 4939953 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674653 | 4939952 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674652 | 4939952 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674650 | 4939952 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674649 | 4939951 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674647 | 4939951 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674646 | 4939951 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674644 | 4939950 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674643 | 4939950 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674641 | 4939950 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674640 | 4939949 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
2 x Palancole | 1674639 | 4939949 | Palancole | STRU | Palancole | AU25 | 0.75 | 0.45 | 0.0145 | 0.0102 | 110.4 | 147 | Ferro
DTM-sdc |  |  | SDC | INQU | DTM | Identificazione - Sistema di riferimento: Gauss-Boaga fuso Ovest
