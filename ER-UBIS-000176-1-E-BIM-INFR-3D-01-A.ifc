Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: IFC4X3_ADD2
File name: ER-UBIS-000176-1-E-INFR-BIM-3D-01-A.ifc
Time: 2025-09-30T10:23:33
Made in: SierraSoft - BIM Exchange - 10.0.0.2509181
Comment: SierraSoft Infra Design Studio (4.0.0.2509181)

# IfcBuiltElement (35)
Testo - WBS_COMMESSA: UBIS176; WBS_DISCIPLINA: INFR; WBS_FASE: E; WBS_LOTTO: 1; WBS_PARTE-OPERA: Budrie
Fasi - Fase di creazione: Stato di progetto
Name | In | Progressiva iniziale (m) | Progressiva finale (m) | Area inclinata (m2) | Area piana (m2) | Volume (m3) | Sviluppo in asse (m) | Sviluppo 2D elemento (m) | Sviluppo 3D elemento (m) | MATERIALE | WBS_COMPONENTE-OPERA | WBS_SUBOPERA
BRECCIOLINO | Ricarica sommità arginale | -1035 | -936.142 | 615.726 | 582.648 | 43.7061 | 98.861 | 100.035 | 100.036 | Pietrisco di pezzatura 40-70mm | BRECCIOLINO [BRECCIOLINO] | Ricarica sommità arginale
BRECCIOLINO | Ricarica sommità arginale | -936 | -785.849 | 1025.8 | 972.345 | 72.9655 | 150.151 | 151.186 | 151.187 | Pietrisco di pezzatura 40-70mm | BRECCIOLINO [BRECCIOLINO] | Ricarica sommità arginale
BRECCIOLINO | Ricarica sommità arginale | -785.232 | 1166.51 | 20798.6 | 20196.4 | 1515.23 | 1951.75 | 1936.25 | 1936.65 | Pietrisco di pezzatura 40-70mm | BRECCIOLINO [BRECCIOLINO] | Ricarica sommità arginale
BRECCIOLINO | Ricarica sommità arginale | 1168 | 1196.79 | 333.639 | 323.934 | 24.2951 | 28.7897 | 29.0414 | 29.1292 | Pietrisco di pezzatura 40-70mm | BRECCIOLINO [BRECCIOLINO] | Ricarica sommità arginale
BRECCIOLINO | Ricarica sommità arginale | 1196.79 | 1196.79 | 0 | 0 | 0 | 0 | 0 | 0 | Pietrisco di pezzatura 40-70mm | BRECCIOLINO [BRECCIOLINO] | Ricarica sommità arginale
BRECCIOLINO | Ricarica sommità arginale | 1198 | 1286.79 | 977.765 | 942.486 | 70.6863 | 88.7897 | 88.7911 | 88.7916 | Pietrisco di pezzatura 40-70mm | BRECCIOLINO [BRECCIOLINO] | Ricarica sommità arginale
BRECCIOLINO | Ricarica sommità arginale | 1286.89 | 1320.89 | 500.116 | 483.897 | 36.3225 | 34.003 | 42.4656 | 42.5736 | Pietrisco di pezzatura 40-70mm | BRECCIOLINO [BRECCIOLINO] | Ricarica sommità arginale
BRECCIOLINO | Ricarica sommità arginale | 1320.94 | 1373.97 | 659.866 | 643.287 | 48.2584 | 53.038 | 54.8263 | 54.8288 | Pietrisco di pezzatura 40-70mm | BRECCIOLINO [BRECCIOLINO] | Ricarica sommità arginale
BRECCIOLINO | Ricarica sommità arginale | 1320.94 | 1320.94 | 0 | 0 | 0 | 0 | 0 | 0 | Pietrisco di pezzatura 40-70mm | BRECCIOLINO [BRECCIOLINO] | Ricarica sommità arginale
BRECCIOLINO | Ricarica sommità arginale | 1374 | 1403.93 | 329.355 | 313.864 | 23.6305 | 29.9348 | 32.6874 | 32.9292 | Pietrisco di pezzatura 40-70mm | BRECCIOLINO [BRECCIOLINO] | Ricarica sommità arginale
BRECCIOLINO | Ricarica sommità arginale | 1403.93 | 1454.23 | 455.144 | 414.904 | 31.1166 | 50.2977 | 52.8456 | 52.9323 | Pietrisco di pezzatura 40-70mm | BRECCIOLINO [BRECCIOLINO] | Ricarica sommità arginale
BRECCIOLINO | Ricarica sommità arginale | 1454.27 | 1502 | 346.097 | 329.899 | 24.7349 | 47.7314 | 47.7444 | 47.7458 | Pietrisco di pezzatura 40-70mm | BRECCIOLINO [BRECCIOLINO] | Ricarica sommità arginale
BRECCIOLINO | Ricarica sommità arginale | 1503.53 | 1558.54 | 404.665 | 386.025 | 28.9548 | 55.0103 | 55.0728 | 55.0737 | Pietrisco di pezzatura 40-70mm | BRECCIOLINO [BRECCIOLINO] | Ricarica sommità arginale
MASSI 3000 | Traversa | 129.692 | 149.982 | 499.392 | 365.217 | 409.181 | 20.2898 | 20.2898 | 20.2898 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso superiore ai 3000kg | MASSI 3000 [MASSICICLOPICI] | Traversa
MASSI 3000 | Traversa | 129.692 | 149.982 | 499.39 | 365.216 | 409.179 | 20.2898 | 20.2898 | 20.2898 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso superiore ai 3000kg | MASSI 3000 [MASSICICLOPICI] | Traversa
MASSI 3000 | Traversa | 149.982 | 150.043 | 1.4985 | 1.0959 | 1.2275 | 0.0607791 | 0.0607975 | 0.0607975 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso superiore ai 3000kg | MASSI 3000 [MASSICICLOPICI] | Traversa
MASSI 3000 | Traversa | 149.982 | 150.043 | 1.496 | 1.0944 | 1.22568 | 0.0607791 | 0.0607606 | 0.0607606 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso superiore ai 3000kg | MASSI 3000 [MASSICICLOPICI] | Traversa
TERRENO VEGETALE | Traversa | 0.000054 | 150.043 | 7142.77 | 6701.08 | 0 | 150.043 | 941.305 | 944.023 | Terreno esistente/ Rilevato | TERRENO VEGETALE [TVEG] | Traversa
MASSI 1000-3000 | Consolidamento alveo | 169.725 | 493.822 | 13485.3 | 11676.9 | 4904.67 | 324.097 | 324.097 | 324.097 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso compreso fra i 1000kg e i 3000kg | MASSI 1000-3000 [PIETRISCO] | Consolidamento alveo
MASSI 3000 | Consolidamento alveo | 150.043 | 169.725 | 1121.72 | 905.606 | 949.616 | 19.6825 | 19.6824 | 19.6824 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso superiore ai 3000kg | MASSI 3000 [MASSICICLOPICI] | Consolidamento alveo
TERRENO VEGETALE | Consolidamento alveo | 150.043 | 493.822 | 11876.5 | 10737.3 | 0 | 343.779 | 2023.22 | 2023.37 | Terreno esistente/ Rilevato | TERRENO VEGETALE [TVEG] | Consolidamento alveo
MASSI 1000-3000 | Integrazione pietrame | 493.822 | 493.828 | 1.2763 | 0.067 | 0.0270844 | 0.00629319 | 1.41859 | 1.52895 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso compreso fra i 1000kg e i 3000kg | MASSI 1000-3000 [PIETRISCO] | Integrazione pietrame
MASSI 1000-3000 | Integrazione pietrame | 493.822 | 944.684 | 5324.81 | 4109.66 | 1750.41 | 450.862 | 451.193 | 451.193 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso compreso fra i 1000kg e i 3000kg | MASSI 1000-3000 [PIETRISCO] | Integrazione pietrame
MASSI 1000-3000 | Integrazione pietrame | 493.828 | 944.684 | 6073.05 | 4973.08 | 2046.6 | 450.856 | 450.606 | 450.606 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso compreso fra i 1000kg e i 3000kg | MASSI 1000-3000 [PIETRISCO] | Integrazione pietrame
MASSI 1000-3000 | Integrazione pietrame | 944.684 | 1196.79 | 3137.96 | 2483.73 | 1042.08 | 252.105 | 251.809 | 251.809 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso compreso fra i 1000kg e i 3000kg | MASSI 1000-3000 [PIETRISCO] | Integrazione pietrame
MASSI 1000-3000 | Integrazione pietrame | 944.684 | 1196.79 | 3457.38 | 2851.45 | 1169.83 | 252.105 | 252.381 | 252.382 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso compreso fra i 1000kg e i 3000kg | MASSI 1000-3000 [PIETRISCO] | Integrazione pietrame
MASSI 1000-3000 | Integrazione pietrame | 1196.79 | 1320.94 | 1609.3 | 1293.41 | 537.766 | 124.146 | 123.958 | 123.958 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso compreso fra i 1000kg e i 3000kg | MASSI 1000-3000 [PIETRISCO] | Integrazione pietrame
MASSI 1000-3000 | Integrazione pietrame | 1196.79 | 1286.79 | 1125.48 | 896.822 | 375.364 | 90 | 89.7106 | 89.7108 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso compreso fra i 1000kg e i 3000kg | MASSI 1000-3000 [PIETRISCO] | Integrazione pietrame
MASSI 1000-3000 | Integrazione pietrame | 1286.89 | 1373.97 | 1174.54 | 959.862 | 395.442 | 87.0866 | 87.7513 | 87.7513 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso compreso fra i 1000kg e i 3000kg | MASSI 1000-3000 [PIETRISCO] | Integrazione pietrame
MASSI 1000-3000 | Integrazione pietrame | 1320.94 | 1354.54 | 383.046 | 292.027 | 125.108 | 33.6033 | 33.5597 | 33.5597 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso compreso fra i 1000kg e i 3000kg | MASSI 1000-3000 [PIETRISCO] | Integrazione pietrame
MASSI 1000-3000 | Integrazione pietrame | 1354.56 | 1403.93 | 495.554 | 387.039 | 159.149 | 49.3779 | 49.342 | 49.4017 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso compreso fra i 1000kg e i 3000kg | MASSI 1000-3000 [PIETRISCO] | Integrazione pietrame
MASSI 1000-3000 | Integrazione pietrame | 1374 | 1403.93 | 289.748 | 226.657 | 92.5471 | 29.9348 | 30.1824 | 30.2142 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso compreso fra i 1000kg e i 3000kg | MASSI 1000-3000 [PIETRISCO] | Integrazione pietrame
MASSI 1000-3000 | Integrazione pietrame | 1403.93 | 1454.23 | 531.914 | 448.467 | 172.72 | 50.2977 | 50.5584 | 50.5647 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso compreso fra i 1000kg e i 3000kg | MASSI 1000-3000 [PIETRISCO] | Integrazione pietrame
MASSI 1000-3000 | Integrazione pietrame | 1404 | 1558.54 | 1406.62 | 1117.86 | 445.325 | 154.537 | 154.951 | 154.969 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso compreso fra i 1000kg e i 3000kg | MASSI 1000-3000 [PIETRISCO] | Integrazione pietrame
MASSI 1000-3000 | Integrazione pietrame | 1454.27 | 1558.54 | 803.221 | 581.707 | 242.158 | 104.268 | 103.68 | 103.68 | Pietrame calcareo proveniente da cava, non gelivo, esente da giunti, fratture o piani di sfaldamento. Certificato CE secondo la UNI EN 13383-1:2013. Elementi di peso compreso fra i 1000kg e i 3000kg | MASSI 1000-3000 [PIETRISCO] | Integrazione pietrame

# IfcElementAssembly, Asse
In: Sito
Testo - WBS_COMPONENTE-OPERA: ASSE; WBS_DISCIPLINA: INFR; WBS_FASE: E; WBS_LOTTO: 1; WBS_PARTE-OPERA: Budrie; WBS_SUBOPERA: ASSE; WBS_COMMESSA: UBIS176
Fasi - Fase di creazione: Stato di progetto
Identificazione - Sistema di riferimento: Gauss-Boaga fuso Ovest

# IfcFacilityPartCommon (4)
In: Sito
UsageType: LONGITUDINAL; PredefinedType: SEGMENT
Testo - WBS_COMMESSA: UBIS176; WBS_DISCIPLINA: INFR; WBS_FASE: E; WBS_LOTTO: 1; WBS_PARTE-OPERA: Budrie
Fasi - Fase di creazione: Stato di progetto
Name | WBS_COMPONENTE-OPERA = WBS_SUBOPERA | Sterro (m3)
Ricarica sommità arginale | RSA | Quantità - Pietrisco di pezzatura 40-70mm: 1525.94 m3
Traversa | TRV | 16808.4 | Quantità - Pietrame calcareo- peso oltre i 3000kg: 878.366 m3; Rilevato: 16066.3 m3
Consolidamento alveo | CSA | 14114.1 | Quantità - Pietrame calcareo- peso oltre i 3000kg: 252.964 m3; Rilevato: 732.89 m3; Pietrame calcareo- peso da 1000 a 3000 kg: 4440.17 m3
Integrazione pietrame | IPI | 5862.55 | Quantità - Pietrame calcareo- peso da 1000 a 3000 kg: 5613.5 m3
