Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: IFC4X3_ADD2
File name: ER-UBIS-000176-1-E-INQU-BIM-3D-03-A.ifc
Time: 2025-09-30T10:23:09
Made in: SierraSoft - BIM Exchange - 10.0.0.2509181
Comment: SierraSoft Infra Design Studio (4.0.0.2509181)

# IfcGeographicElement, DTM-sdp
In: Sito
PredefinedType: TERRAIN
Testo - WBS_COMMESSA: UBIS176; WBS_DISCIPLINA: INQU; WBS_FASE: E; WBS_LOTTO: 1; WBS_PARTE-OPERA: Budrie; WBS_SUBOPERA: DTM; WBS_COMPONENTE-OPERA: SDP
Fasi - Fase di creazione: Stato di progetto
Identificazione - Sistema di riferimento: Gauss-Boaga fuso Ovest
